# Keil uVision project RS485_SLAVE_PROGRAME.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RS485_SLAVE_PROGRAME +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\USER;.\CORE;.\DEMO;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\STM32F10x_FWLib\inc;.\HARDWARE\CRC16;.\HARDWARE\LED;.\HARDWARE\RS485;.\HARDWARE\TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group HAREWARD
    ./HARDWARE/CRC16/: crc16.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/RS485/: rs485.c
    ./HARDWARE/TIMER/: timer.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group CODE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_crc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_usart.c
  group DEMO
    ./DEMO/: demo.c
