# Keil uVision project TestBoard.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: modbusmasterRTU +hex (library)
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\SRC;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Core\CM3;..\SRC\Parameters\BLSX
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
  group SRC
    ../SRC/: MBcrc.c MBMasterFunc.c MBMasterRtu.c MBMasterTimer.c ModbusMaster.c Quene.c SystemInit.c Timers.c
  group LIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
  group CMSIS
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
